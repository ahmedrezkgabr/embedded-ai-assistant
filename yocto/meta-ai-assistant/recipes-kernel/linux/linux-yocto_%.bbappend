KERNEL_FEATURES:append = " features/sound/alsa-state.scc"
